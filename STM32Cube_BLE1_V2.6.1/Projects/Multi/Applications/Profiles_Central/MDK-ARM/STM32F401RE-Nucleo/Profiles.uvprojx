# Keil uVision project Profiles.uvprojx, settings and files
target ProfCentr_STM32F401RE_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProfCentr_F401RE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F401xE,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99 --gnu
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Prof_Centr\includes;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc;..\..\..\..\..\..\Middlewares\ST\TimerServer\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../../Src/: anc_central_application.c ans_central_application.c bluenrg_interface.c bp_central_application.c clock.c cube_hal_f4.c fml_central_application.c fmt_central_application.c gc_central_application.c hid_central_application.c hr_central_application.c ht_central_application.c main.c pas_central_application.c pm_central_application.c pr_central_application.c stm32xx_it.c tc_central_application.c ts_central_application.c uart_support.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32F4xx_NUCLEO
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middlewares/STM32_BlueNRG/BlueProfileLib
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Prof_Centr_Lib/MDK-ARM/F4/: BLEProfilesLib.lib
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c ble_list.c osal.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Prof_Periph/utils/: timer.c
  group Middlewares/TimerServer
    ../../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
