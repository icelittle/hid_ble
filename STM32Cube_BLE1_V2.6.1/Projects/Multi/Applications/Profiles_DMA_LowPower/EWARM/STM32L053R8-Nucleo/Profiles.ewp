# IAR project Profiles.ewp, settings and files
configuration STM32L053R8_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; __DMA_LP__
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Prof_Periph\includes; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\LowPowerManager\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1; ..\..\..\..\..\..\Middlewares\ST\TimerServer\inc; ..\..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\STM32L0xx_HAL_BlueNRG_Drivers\inc; ..\..\STM32xx_HAL_APP_Drivers\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Profiles.bin
  ILINK.IlinkOutputFile: BlueNRG_Profiles.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/HAL_APP_Drivers
    ../../STM32xx_HAL_APP_Drivers/src/: stm32xx_hal_app_rtc.c
  group Application/User
    ../../Src/: anc_profile_application.c ans_profile_application.c bluenrg_interface.c bps_profile_application.c clock.c cube_hal_l0.c fml_profile_application.c fmt_profile_application.c gs_profile_application.c hid_profile_application.c hrm_profile_application.c htm_profile_application.c low_power_conf_l0.c main.c pac_profile_application.c pm_profile_application.c pr_profile_application.c profile_application.c stm32xx_it.c tc_profile_application.c ts_profile_application.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c stm32l0xx_nucleo_bluenrg_dma_lp.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble_dma_lp.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c
  group Middlewares/LPM
    ../../../../../../Middlewares/ST/LowPowerManager/Src/: stm32xx_lpm.c
  group Middlewares/STM32_BlueNRG/BLEProfilesLib
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Prof_Periph_Lib/EWARM/L0/: BLEProfilesLib.a
  group Middlewares/STM32_BlueNRG/HAL_Drivers
    ../../../../../../Middlewares/ST/STM32_BlueNRG/STM32L0xx_HAL_BlueNRG_Drivers/src/: stm32l0xx_hal_bluenrg_gpio.c stm32l0xx_hal_bluenrg_syscfg.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci_dma_lp.c
  group Middlewares/STM32_BlueNRG/HCI/Controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c ble_list.c osal.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Prof_Periph/utils/: timer.c
  group Middlewares/TimerServer
    ../../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
